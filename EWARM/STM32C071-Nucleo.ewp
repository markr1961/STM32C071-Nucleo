# IAR project STM32C071-Nucleo.ewp, settings and files
configuration STM32C071-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32C071RB ST STM32C071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_NUCLEO_64; USE_HAL_DRIVER; STM32C071xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32C0xx_HAL_Driver/Inc; ../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy; ../Drivers/BSP/STM32C0xx_Nucleo; ../Drivers/CMSIS/Device/ST/STM32C0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32C071-Nucleo.hex
  ILINK.IlinkOutputFile: STM32C071-Nucleo.out
  ILINK.IlinkIcfFile: stm32c071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32c071xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Drivers/BSP/STM32C0xx_Nucleo
    ../Drivers/BSP/STM32C0xx_Nucleo/: stm32c0xx_nucleo.c
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c stm32c0xx_ll_rcc.c stm32c0xx_ll_utils.c stm32c0xx_ll_exti.c stm32c0xx_ll_gpio.c stm32c0xx_hal_rtc.c stm32c0xx_hal_rtc_ex.c stm32c0xx_hal_usart.c stm32c0xx_hal_usart_ex.c stm32c0xx_hal_uart_ex.c stm32c0xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
